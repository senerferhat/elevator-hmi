# Same Mali CMake hole: HAVE_EGL failed, so target qtsvg shipped empty
# (~6 KB) RPMs. qtdeclarative then reports Qt6Svg not found.

require mali-egl-cmake.inc
